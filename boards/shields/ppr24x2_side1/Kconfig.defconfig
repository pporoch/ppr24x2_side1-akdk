## boards/shields/ppr24x2_side1/Kconfig.defconfig
```kconfig
if SHIELD_PPR24X2_SIDE1
config ZMK_KEYBOARD_NAME
    default "ppr24x2_side1"

endif
```
